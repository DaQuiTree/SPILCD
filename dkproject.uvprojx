# Keil uVision project dkproject.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Exectable +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F427_437xx
  c include: ..\..\libraries\CMSIS\Include;..\..\libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\libraries\CMSIS\Device\ST\STM32F4xx\Source;..\..\libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\libraries\STM32F4xx_StdPeriph_Driver\src;..\..\libraries\Template
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group StartupCode
    ../../libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
  group CMSIS
    ../../libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../../libraries/CMSIS/Device/ST/STM32F4xx/Include/: system_stm32f4xx.h stm32f4xx.h
    ../../libraries/CMSIS/Include/: core_cm4.h
  group App
    ./App/: main.c
    ../../libraries/Template/: stm32f4xx_conf.h
  group Doc
    ./Doc/: ReadMe.txt
